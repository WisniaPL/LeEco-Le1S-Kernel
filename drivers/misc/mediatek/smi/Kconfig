## drivers/misc/mediatek/smi/Kconfig
```kconfig
config MTK_SMI_EXT
	bool "SMI Driver"
	default y
	help
	  SMI Driver is used to arbitrate memory bandwidth of multimedia
```
